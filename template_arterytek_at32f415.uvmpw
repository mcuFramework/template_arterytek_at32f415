<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>WorkSpace</WorkspaceName>

  <project>
    <PathAndName>.\template_arterytek_at32f415.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>..\core_arterytek_at32f415\core_arterytek_at32f415.uvprojx</PathAndName>
    <NodeIsActive>1</NodeIsActive>
  </project>

  <project>
    <PathAndName>..\bsp_arterytek_at32f415\bsp_arterytek_at32f415.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>..\macro\macro.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>..\mcuf\mcuf.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>..\os_cmsis_rtos\os_cmsis_rtos.uvprojx</PathAndName>
  </project>

</ProjectWorkspace>
