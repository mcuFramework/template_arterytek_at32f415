# Keil uVision project template_arterytek_at32f415.uvprojx, settings and files
target template_arterytek_at32f415 (6160000::V6.16::ARMCLANG)
  device: -AT32F415R8T7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.0.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: template_arterytek_at32f415
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F415RBT7
  c include: ..\
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src/setup
    ./setup/: Entry.cpp Entry.h Lowlevel.cpp Main.cpp
  group src/reference
    ./reference/: core_arterytek_interrupt.cpp core_arterytek_interrupt_priority.c core_arterytek_startup.s mcuf_lib.cpp mcuf_config.h
  group library
    ../os_cmsis_rtos/: os_cmsis_rtos_m4.lib
    ../mcuf/: mcuf_m4.lib
    ../core_arterytek_at32f415/: core_arterytek_at32f415.lib
    ../bsp_arterytek_at32f415/: bsp_arterytek_at32f415.lib
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3
